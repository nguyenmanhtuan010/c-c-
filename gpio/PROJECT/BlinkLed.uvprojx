# Keil uVision project BlinkLed.uvprojx, settings and files
target GPIO (::::)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BlinkLed
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\LIB\CMSIS\CM3\CoreSupport;..\PROJECT;..\LIB\STM32F10x_StdPeriph_Driver\inc;..\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LIB
    ../LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group LIB_USER
    ../USER/: gpio.h rcc.h
